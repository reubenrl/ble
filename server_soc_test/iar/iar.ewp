# IAR project iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG1P232F256GM48 SiliconLaboratories EFR32BG1P232F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32BG1P232F256GM48; HAL_CONFIG=1; __NO_SYSTEM_INIT=1
  ICCARM.CCDiagSuppress: pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..; D:\GitWorkspace\siliconlabs\ble\server_soc_test; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\CMSIS\Include; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\radio\rail_lib\common; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\radio\rail_lib\chip\efr32; D:\GitWorkspace\siliconlabs\ble\server_soc_test\hardware\kit\common\drivers; D:\GitWorkspace\siliconlabs\ble\server_soc_test\hardware\kit\EFR32BG1_BRD4100A\config; D:\GitWorkspace\siliconlabs\ble\server_soc_test\hardware\kit\common\bsp; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\emlib\inc; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\emdrv\common\inc; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\emdrv\dmadrv\inc; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\emdrv\gpiointerrupt\inc; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\emdrv\sleep\inc; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\emdrv\uartdrv\config; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\emdrv\uartdrv\inc; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\Device\SiliconLabs\EFR32BG1P\Include; D:\GitWorkspace\siliconlabs\ble\server_soc_test\protocol\bluetooth_2.6\ble_stack\inc\common; D:\GitWorkspace\siliconlabs\ble\server_soc_test\protocol\bluetooth_2.6\ble_stack\inc\soc; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\bootloader\api; D:\GitWorkspace\siliconlabs\ble\server_soc_test\app\bluetooth_2.6\common\stack_bridge; D:\GitWorkspace\siliconlabs\ble\server_soc_test\hardware\kit\common\halconfig; D:\GitWorkspace\siliconlabs\ble\server_soc_test\platform\halconfig\inc\hal-config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: soc-empty.bin
  ILINK.IlinkOutputFile: soc-empty.out
  ILINK.IlinkIcfFile: ../EFR32BG1P232F256GM48.icf
  ILINK.IlinkExtraOptions: --keep __iar_program_start; --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  group (top)
    D:/GitWorkspace/siliconlabs/ble/server_soc_test/: main.c application_properties.c pti.c init_mcu.c init_board.c init_app.c
    D:/GitWorkspace/siliconlabs/ble/server_soc_test/hardware/kit/common/drivers/: mx25flash_spi.c
    D:/GitWorkspace/siliconlabs/ble/server_soc_test/platform/emlib/src/: em_cmu.c em_system.c em_gpio.c em_i2c.c em_rtcc.c em_usart.c em_msc.c em_cryotimer.c em_leuart.c em_adc.c em_ldma.c
    D:/GitWorkspace/siliconlabs/ble/server_soc_test/platform/Device/SiliconLabs/EFR32BG1P/Source/IAR/: startup_efr32bg1p.c
    D:/GitWorkspace/siliconlabs/ble/server_soc_test/platform/emdrv/dmadrv/src/: dmadrv.c
    D:/GitWorkspace/siliconlabs/ble/server_soc_test/hardware/kit/common/bsp/: bsp_stk.c
    D:/GitWorkspace/siliconlabs/ble/server_soc_test/./: gatt_db.c
  group gattdb
    ../: gatt.xml
  group lib
    D:/GitWorkspace/siliconlabs/ble/server_soc_test/protocol/bluetooth_2.6/lib/EFR32BG1P/EABI/: stack.a binstack.o binbootloader.o bgapi.a
